# Repository terriblefire/cd32_riser

File README.md:

# cd32_riser

Experimental CD32 Riser with USB Support. Very much work in progress. The code is not good right now.

## EAGLE design eagle/cd32_riser.brd

Parts:
U$3: 25PINCUSTOM

Connections:
+12V: U$3.P$23; also elsewhere on the board
AB_OUT: U$3.P$5; also elsewhere on the board
AG_OUT: U$3.P$4; also elsewhere on the board
AR_OUT: U$3.P$3; also elsewhere on the board
GND: U$3.P$17, U$3.P$18, U$3.P$19, U$3.P$20, U$3.P$21; also elsewhere on the board
VCC: U$3.P$24; also elsewhere on the board
_CSYNC: U$3.P$10; also elsewhere on the board
_HSYNC: U$3.P$11; also elsewhere on the board
_VSYNC: U$3.P$12; also elsewhere on the board

Parts:
CN1, CN2: CD32-EXPANSION; CD32_EXPANSION_182_MCA

Connections:
+12V: CN1.P$136 (+12V), CN1.P$138 (+12V), CN1.P$178 (+12V), CN2.P$136 (+12V), CN2.P$138 (+12V), CN2.P$178 (+12V); also elsewhere on the board
A0: CN1.P$38 (A0), CN2.P$38 (A0); also elsewhere on the board
A1: CN1.P$37 (A1), CN2.P$37 (A1); also elsewhere on the board
A2: CN1.P$36 (A2), CN2.P$36 (A2); also elsewhere on the board
A3: CN1.P$35 (A3), CN2.P$35 (A3); also elsewhere on the board
A4: CN1.P$34 (A4), CN2.P$34 (A4); also elsewhere on the board
A5: CN1.P$33 (A5), CN2.P$33 (A5); also elsewhere on the board
A6: CN1.P$32 (A6), CN2.P$32 (A6); also elsewhere on the board
A7: CN1.P$31 (A7), CN2.P$31 (A7); also elsewhere on the board
A8: CN1.P$28 (A8), CN2.P$28 (A8); also elsewhere on the board
A9: CN1.P$27 (A9), CN2.P$27 (A9); also elsewhere on the board
A10: CN1.P$26 (A10), CN2.P$26 (A10); also elsewhere on the board
A11: CN1.P$25 (A11), CN2.P$25 (A11); also elsewhere on the board
A12: CN1.P$24 (A12), CN2.P$24 (A12); also elsewhere on the board
A13: CN1.P$23 (A13), CN2.P$23 (A13); also elsewhere on the board
A14: CN1.P$22 (A14), CN2.P$22 (A14); also elsewhere on the board
A15: CN1.P$21 (A15), CN2.P$21 (A15); also elsewhere on the board
A16: CN1.P$18 (A16), CN2.P$18 (A16); also elsewhere on the board
A17: CN1.P$17 (A17), CN2.P$17 (A17); also elsewhere on the board
A18: CN1.P$16 (A18), CN2.P$16 (A18); also elsewhere on the board
A19: CN1.P$15 (A19), CN2.P$15 (A19); also elsewhere on the board
A20: CN1.P$14 (A20), CN2.P$14 (A20); also elsewhere on the board
A21: CN1.P$13 (A21), CN2.P$13 (A21); also elsewhere on the board
A22: CN1.P$12 (A22), CN2.P$12 (A22); also elsewhere on the board
A23: CN1.P$11 (A23), CN2.P$11 (A23); also elsewhere on the board
A24: CN1.P$8 (A24), CN2.P$8 (A24)
A25: CN1.P$7 (A25), CN2.P$7 (A25)
A26: CN1.P$6 (A26), CN2.P$6 (A26)
A27: CN1.P$5 (A27), CN2.P$5 (A27)
A28: CN1.P$4 (A28), CN2.P$4 (A28)
A29: CN1.P$3 (A29), CN2.P$3 (A29)
A30: CN1.P$2 (A30), CN2.P$2 (A30)
A31: CN1.P$1 (A31), CN2.P$1 (A31)
AB: CN1.P$168 (AB), CN2.P$168 (AB)
AB_EXT: CN1.P$167 (AB_EXT), CN2.P$167 (AB_EXT); also elsewhere on the board
AG: CN1.P$166 (AG), CN2.P$166 (AG)
AGND: CN1.P$177 (AGND), CN2.P$177 (AGND)
AG_EXT: CN1.P$165 (AG_EXT), CN2.P$165 (AG_EXT); also elsewhere on the board
AR: CN1.P$164 (AR), CN2.P$164 (AR)
AR_EXT: CN1.P$163 (AR_EXT), CN2.P$163 (AR_EXT); also elsewhere on the board
CCK_B: CN1.P$158 (CCK_B), CN2.P$158 (CCK_B)
CLK17MHZ: CN1.P$139 (17MHZ), CN2.P$139 (17MHZ)
CPUCLK_A: CN1.P$99 (CPUCLK_A), CN2.P$99 (CPUCLK_A); also elsewhere on the board
D0: CN1.P$78 (D0), CN2.P$78 (D0)
D1: CN1.P$77 (D1), CN2.P$77 (D1)
D2: CN1.P$76 (D2), CN2.P$76 (D2)
D3: CN1.P$75 (D3), CN2.P$75 (D3)
D4: CN1.P$74 (D4), CN2.P$74 (D4)
D5: CN1.P$73 (D5), CN2.P$73 (D5)
D6: CN1.P$72 (D6), CN2.P$72 (D6)
D7: CN1.P$71 (D7), CN2.P$71 (D7)
D8: CN1.P$68 (D8), CN2.P$68 (D8)
D9: CN1.P$67 (D9), CN2.P$67 (D9)
D10: CN1.P$66 (D10), CN2.P$66 (D10)
D11: CN1.P$65 (D11), CN2.P$65 (D11)
D12: CN1.P$64 (D12), CN2.P$64 (D12)
D13: CN1.P$63 (D13), CN2.P$63 (D13)
D14: CN1.P$62 (D14), CN2.P$62 (D14)
D15: CN1.P$61 (D15), CN2.P$61 (D15)
D16: CN1.P$58 (D16), CN2.P$58 (D16)
D17: CN1.P$57 (D17), CN2.P$57 (D17)
D18: CN1.P$56 (D18), CN2.P$56 (D18)
D19: CN1.P$55 (D19), CN2.P$55 (D19)
D20: CN1.P$54 (D20), CN2.P$54 (D20)
D21: CN1.P$53 (D21), CN2.P$53 (D21)
D22: CN1.P$52 (D22), CN2.P$52 (D22)
D23: CN1.P$51 (D23), CN2.P$51 (D23)
D24: CN1.P$48 (D24), CN2.P$48 (D24); also elsewhere on the board
D25: CN1.P$47 (D25), CN2.P$47 (D25); also elsewhere on the board
D26: CN1.P$46 (D26), CN2.P$46 (D26); also elsewhere on the board
D27: CN1.P$45 (D27), CN2.P$45 (D27); also elsewhere on the board
D28: CN1.P$44 (D28), CN2.P$44 (D28); also elsewhere on the board
D29: CN1.P$43 (D29), CN2.P$43 (D29); also elsewhere on the board
D30: CN1.P$42 (D30), CN2.P$42 (D30); also elsewhere on the board
D31: CN1.P$41 (D31), CN2.P$41 (D31); also elsewhere on the board
DA_BCLK: CN1.P$144 (DA_BCLK), CN2.P$144 (DA_BCLK)
DA_DATA: CN1.P$141 (DA_DATA), CN2.P$141 (DA_DATA)
DA_LRCLK: CN1.P$143 (DA_LRCLK), CN2.P$143 (DA_LRCLK)
DB: CN1.P$149 (DB), CN2.P$149 (DB)
DG: CN1.P$148 (DG), CN2.P$148 (DG)
DI: CN1.P$150 (DI), CN2.P$150 (DI)
DKWE: CN1.P$132 (DKWE), CN2.P$132 (DKWE); also elsewhere on the board
DR: CN1.P$147 (DR), CN2.P$147 (DR)
FC0: CN1.P$105 (FC_0), CN2.P$105 (FC_0)
FC1: CN1.P$104 (FC_1), CN2.P$104 (FC_1)
FC2: CN1.P$103 (FC_2), CN2.P$103 (FC_2)
GND: CN1.P$9 (GND), CN1.P$19 (GND), CN1.P$29 (GND), CN1.P$39 (GND), CN1.P$49 (GND), CN1.P$59 (GND), CN1.P$69 (GND), CN1.P$79 (GND), CN1.P$101 (GND), CN1.P$131 (GND), CN1.P$133 (GND), CN1.P$135 (GND), CN1.P$137 (GND), CN1.P$145 (GND), CN1.P$155 (GND), CN1.P$175 (GND), CN2.P$9 (GND), CN2.P$19 (GND), CN2.P$29 (GND), CN2.P$39 (GND), CN2.P$49 (GND), CN2.P$59 (GND), CN2.P$69 (GND), CN2.P$79 (GND), CN2.P$101 (GND), CN2.P$131 (GND), CN2.P$133 (GND), CN2.P$135 (GND), CN2.P$137 (GND), CN2.P$145 (GND), CN2.P$155 (GND), CN2.P$175 (GND); also elsewhere on the board
IPL0: CN1.P$83 (_IPL0), CN2.P$83 (_IPL0)
IPL1: CN1.P$82 (_IPL1), CN2.P$82 (_IPL1)
IPL2: CN1.P$81 (_IPL2), CN2.P$81 (_IPL2)
LEFT: CN1.P$180 (LEFT), CN2.P$180 (LEFT)
LEFT_EXT: CN1.P$179 (LEFT_EXT), CN2.P$179 (LEFT_EXT)
NC@1: CN1.P$84 (NC), CN2.P$84 (NC)
NC@2: CN1.P$89 (NC), CN2.P$89 (NC)
NC@3: CN1.P$90 (NC), CN2.P$90 (NC)
NC@4: CN1.P$95 (NC), CN2.P$95 (NC)
NC@5: CN1.P$100 (NC), CN2.P$100 (NC)
NC@6: CN1.P$107 (NC), CN2.P$107 (NC)
NC@7: CN1.P$108 (NC), CN2.P$108 (NC)
NC@8: CN1.P$109 (NC), CN2.P$109 (NC)
NC@9: CN1.P$110 (NC), CN2.P$110 (NC)
NC@10: CN1.P$115 (NC), CN2.P$115 (NC)
NC@11: CN1.P$116 (NC), CN2.P$116 (NC)
NC@12: CN1.P$134 (NC), CN2.P$134 (NC)
PIXELCLK: CN1.P$154 (PIXELCLK), CN2.P$154 (PIXELCLK)
PUNT_IN: CN2.P$117 (_PUNT); also elsewhere on the board
PUNT_OUT: CN1.P$117 (_PUNT); also elsewhere on the board
RIGHT: CN1.P$182 (RIGHT), CN2.P$182 (RIGHT)
RIGHT_EXT: CN1.P$181 (RIGHT_EXT), CN2.P$181 (RIGHT_EXT)
R_W: CN1.P$93 (R_W), CN2.P$93 (R_W); also elsewhere on the board
SIZ0: CN1.P$88 (SIZE_0), CN2.P$88 (SIZE_0)
SIZ1: CN1.P$87 (SIZE_1), CN2.P$87 (SIZE_1)
VCC: CN1.P$10 (VCC), CN1.P$20 (VCC), CN1.P$30 (VCC), CN1.P$40 (VCC), CN1.P$50 (VCC), CN1.P$60 (VCC), CN1.P$70 (VCC), CN1.P$80 (VCC), CN1.P$102 (VCC), CN1.P$146 (VCC), CN1.P$156 (VCC), CN1.P$176 (VCC), CN2.P$10 (VCC), CN2.P$20 (VCC), CN2.P$30 (VCC), CN2.P$40 (VCC), CN2.P$50 (VCC), CN2.P$60 (VCC), CN2.P$70 (VCC), CN2.P$80 (VCC), CN2.P$102 (VCC), CN2.P$146 (VCC), CN2.P$156 (VCC), CN2.P$176 (VCC); also elsewhere on the board
VGND: CN1.P$161 (VGND), CN1.P$162 (VGND), CN1.P$169 (VGND), CN1.P$170 (VGND), CN2.P$161 (VGND), CN2.P$162 (VGND), CN2.P$169 (VGND), CN2.P$170 (VGND)
XCLK: CN1.P$173 (XCLK), CN2.P$173 (XCLK)
_ACTIVE: CN1.P$126 (_ACTIVE), CN2.P$126 (_ACTIVE); also elsewhere on the board
_AS: CN1.P$91 (_AS), CN2.P$91 (_AS); also elsewhere on the board
_AVEC: CN1.P$96 (_AVEC), CN2.P$96 (_AVEC)
_BEER: CN1.P$94 (_BEER), CN2.P$94 (_BEER)
_BLANK: CN1.P$153 (_BLANK), CN2.P$153 (_BLANK)
_CPU_BG: CN1.P$113 (_CPU_BG), CN2.P$113 (_CPU_BG)
_CPU_BR: CN1.P$111 (_CPU_BR), CN2.P$111 (_CPU_BR)
_CSYNC: CN1.P$157 (_CSYNC), CN2.P$157 (_CSYNC); also elsewhere on the board
_DKRD: CN1.P$129 (_DKRD), CN2.P$129 (_DKRD); also elsewhere on the board
_DKWD: CN1.P$130 (_DKWD), CN2.P$130 (_DKWD); also elsewhere on the board
_DS: CN1.P$92 (_DS), CN2.P$92 (_DS); also elsewhere on the board
_DSACK_0: CN1.P$98 (_DSACK_0), CN2.P$98 (_DSACK_0); also elsewhere on the board
_DSACK_1: CN1.P$97 (_DSACK_1), CN2.P$97 (_DSACK_1); also elsewhere on the board
_EXP_BG: CN1.P$112 (_EXP_BG), CN2.P$112 (_EXP_BG)
_EXP_BR: CN1.P$114 (_EXP_BR), CN2.P$114 (_EXP_BR)
_EXT_AUDIO: CN1.P$140 (_EXT_AUDIO), CN2.P$140 (_EXT_AUDIO)
_EXT_VIDEO: CN1.P$174 (_EXT_VIDEO), CN2.P$174 (_EXT_VIDEO)
_FIRE0: CN1.P$123 (_FIRE0), CN2.P$123 (_FIRE0); also elsewhere on the board
_FIRE1: CN1.P$124 (_FIRE1), CN2.P$124 (_FIRE1); also elsewhere on the board
_HLT: CN1.P$86 (_HLT), CN2.P$86 (_HLT)
_HSYNC: CN1.P$159 (_HSYNC), CN2.P$159 (_HSYNC); also elsewhere on the board
_INT2: CN1.P$119 (_INT2), CN2.P$119 (_INT2)
_INT6: CN1.P$120 (_INT6), CN2.P$120 (_INT6)
_KB_CLOCK: CN1.P$121 (_KB_CLOCK), CN2.P$121 (_KB_CLOCK); also elsewhere on the board
_KB_DATA: CN1.P$122 (_KB_DATA), CN2.P$122 (_KB_DATA); also elsewhere on the board
_LED: CN1.P$125 (_LED), CN2.P$125 (_LED)
_MUTE: CN1.P$142 (_MUTE), CN2.P$142 (_MUTE)
_NTSC: CN1.P$171 (_NTSC), CN2.P$171 (_NTSC)
_PIXELSW: CN1.P$152 (_PIXELSW), CN2.P$152 (_PIXELSW)
_PIXELSW_EXT: CN1.P$151 (_PIXELSW_EXT), CN2.P$151 (_PIXELSW_EXT)
_RESET: CN1.P$118 (_RESET), CN2.P$118 (_RESET)
_RMC: CN1.P$106 (_RMC), CN2.P$106 (_RMC)
_RST: CN1.P$85 (_RST), CN2.P$85 (_RST)
_RXD: CN1.P$127 (_RXD), CN2.P$127 (_RXD); also elsewhere on the board
_TXD: CN1.P$128 (_TXD), CN2.P$128 (_TXD); also elsewhere on the board
_VSYNC: CN1.P$160 (_VSYNC), CN2.P$160 (_VSYNC); also elsewhere on the board
_XCLKEN: CN1.P$172 (_XCLKEN), CN2.P$172 (_XCLKEN)

Parts:
BOOT0: JP2E; JP2
C1: 100nF; C1206
C2, C4, C5, C6, C7, C8, C9, C12, C14, C25: 100n; C0603
C3: 10u; C0603
C10, C11, C23, C24: 22p; C0603
C13: 10uF; C1206
C15: 100n; R0603
C16: 100nF; C0603
C22: 100n; C0805
D1: BAT54; SOT23
DAC: JUMPER-3PTH; 1X03
F1, F2: 0R; R1206
G1: CH23-1220LF
IC1: LM1117MPX-3.3; SOT223
IC3: STM32F722RET6; QFP50P1200X1200X160-64N
IC4: THS7314D; SOIC127P599X175-8N
JP1, JP3: JUMPER-2PTH; 1X02
JP2: JP3Q
LED2: LED; SML0805
PA9BOOT: JP2E; JP2
PWR: LED; SML0805
R2, R5, R6, R7: 100K; M0805
R3, R4: 10k; R0603
U$1: USB-A-2_USB_USB-A-2
X1: SMD-CRYSTAL-8MHZ-20PF-20PPM(2P-5.0X3.2MM); X2-SMD-5.0X3.2X1.3MM
X2: SMD-CRYSTAL-32768KHZ-20PF-20PPM(2P-5.0X3.2MM); X2-SMD-5.0X3.2X1.3MM

Connections:
A0: IC3.24 (PC4); also elsewhere on the board
A1: IC3.37 (PC6); also elsewhere on the board
A2: IC3.38 (PC7); also elsewhere on the board
A4: IC3.43 (PA10); also elsewhere on the board
A5: IC3.11 (PC3); also elsewhere on the board
AB_EXT: IC4.1 (CH_1_IN), R5.2; also elsewhere on the board
AB_OUT: IC4.8 (CH_1_OUT); also elsewhere on the board
AG_EXT: IC4.2 (CH_2_IN), R6.1; also elsewhere on the board
AG_OUT: IC4.7 (CH_2_OUT); also elsewhere on the board
AR_EXT: IC4.3 (CH_3_IN), R7.1; also elsewhere on the board
AR_OUT: IC4.6 (CH_3_OUT); also elsewhere on the board
BOOT: BOOT0.2, IC3.60 (BOOT)
BUS_INT: IC3.61 (PB8); also elsewhere on the board
D24: IC3.25 (PB0); also elsewhere on the board
D25: IC3.26 (PB1); also elsewhere on the board
D26: IC3.27 (PB2); also elsewhere on the board
D27: IC3.55 (PB3(JTDO/TRACESWO)); also elsewhere on the board
D28: IC3.56 (PB4(!JTRST)); also elsewhere on the board
D29: IC3.57 (PB5); also elsewhere on the board
D30: IC3.58 (PB6); also elsewhere on the board
D31: IC3.59 (PB7); also elsewhere on the board
DAC1: DAC.1, IC3.20 (PA4)
DAC2: DAC.3, IC3.21 (PA5)
DKWE: IC3.16 (PA2); also elsewhere on the board
GND: BOOT0.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C22.2, C23.2, C24.2, C25.2, DAC.2, G1.-, IC1.1 (GND), IC3.12 (VSSA), IC3.18 (VSS), IC3.31 (VSS), IC3.47 (VSS), IC3.63 (VSS), IC4.5 (GND), JP2.2, PA9BOOT.1, PWR.C, R5.1, R6.2, R7.2, U$1.1-4, U$1.2-4, U$1.SHIELD1, U$1.SHIELD2, U$1.SHIELD3, U$1.SHIELD4; also elsewhere on the board
INTSIG1: IC3.62 (PB9); also elsewhere on the board
INTSIG2: IC3.33 (PB12); also elsewhere on the board
INTSIG3: IC3.50 (PA15(JTDI)); also elsewhere on the board
INTSIG4: IC3.39 (PC8); also elsewhere on the board
INTSIG5: IC3.40 (PC9); also elsewhere on the board
INTSIG6: IC3.51 (PC10); also elsewhere on the board
INTSIG7: IC3.52 (PC11); also elsewhere on the board
INTSIG8: IC3.14 (PA0-WKUP); also elsewhere on the board
LED: IC3.34 (PB13), LED2.C
LSE_OSCIN: C23.1, IC3.3 (PC14-OSC32_IN), X2.2, X2.P$2
LSE_OSCOUT: C24.1, IC3.4 (PC15-OSC32_OUT), X2.1, X2.P$1
unnamed: F1.2, U$1.2-1
unnamed: F2.2, U$1.1-1
unnamed: LED2.A, R4.2
unnamed: D1.1 (A), G1.+
unnamed: PWR.A, R3.2
NRST: C7.1, IC3.7 (!RST), JP2.4, R2.1
OSCIN: C10.1, IC3.5 (PH0-OSC_IN), X1.2
OSCOUT: C11.1, IC3.6 (PH1-OSC_OUT), X1.1
PA9BOOT: IC3.42 (PA9), PA9BOOT.2
R_W: IC3.2 (PC13); also elsewhere on the board
SPI2_CK: IC3.28 (PB10); also elsewhere on the board
SPI2_MISO: IC3.10 (PC2); also elsewhere on the board
SPI2_MOSI: IC3.9 (PC1); also elsewhere on the board
SWCLK: IC3.49 (PA14(JTCK-SWCLK)), JP2.5
SWDIO: IC3.46 (PA13(JTMS-SWDIO)), JP2.6
UART5_RX: IC3.54 (PD2), JP1.1
UART5_TX: IC3.53 (PC12), JP1.2
USB1_DM: IC3.44 (PA11), U$1.2-2
USB1_DP: IC3.45 (PA12), U$1.2-3
USB2_DM: IC3.35 (PB14), U$1.1-2
USB2_DP: IC3.36 (PB15), U$1.1-3
VBAT: D1.3 (C), IC3.1 (VBAT)
VCAP: C22.1, IC3.30 (VCAP_1)
VCC: C1.1, C3.1, C25.1, F1.1, F2.1, IC1.3 (IN), IC4.4 (VS_P), JP2.1, PA9BOOT.3, R4.1; also elsewhere on the board
VCC33: BOOT0.3, C2.1, C4.1, C5.1, C6.1, C8.1, C9.1, C12.1, C13.1, C14.1, C15.1, C16.1, IC1.2 (OUT), IC1.TAB (OUT1), IC3.13 (VREF+), IC3.19 (VDD), IC3.32 (VDD), IC3.48 (VDD), IC3.64 (VDD), JP2.3, R2.2, R3.1; also elsewhere on the board
_ACTIVE: IC3.22 (PA6); also elsewhere on the board
_DKRD: IC3.23 (PA7); also elsewhere on the board
_DKWD: IC3.41 (PA8); also elsewhere on the board
_FIRE0: IC3.17 (PA3); also elsewhere on the board
_FIRE1: IC3.8 (PC0); also elsewhere on the board
_KB_CLOCK: IC3.29 (PB11); also elsewhere on the board
_KB_DATA: IC3.15 (PA1); also elsewhere on the board
_RXD: JP3.2; also elsewhere on the board
_TXD: JP3.1; also elsewhere on the board

Notes on the sheet:
Debug Console

Parts:
C17, C18, C19, C20, C21: 0.1uF; C0603
IC2: XC9572XL-VQ64; VQ64
JTAG: JTAG; 1X06_ROUND
R1: 4K7; M1206

Connections:
A0: IC2.27 (PB03/9); also elsewhere on the board
A1: IC2.25 (PB03/8); also elsewhere on the board
A2: IC2.31 (PB03/3); also elsewhere on the board
A3: IC2.32 (PB03/4); also elsewhere on the board
A4: IC2.33 (PB03/11); also elsewhere on the board
A5: IC2.34 (PB03/6); also elsewhere on the board
A6: IC2.35 (PB03/14); also elsewhere on the board
A7: IC2.36 (PB03/15); also elsewhere on the board
A8: IC2.38 (PB03/17); also elsewhere on the board
A9: IC2.39 (PB03/10); also elsewhere on the board
A10: IC2.40 (PB03/12); also elsewhere on the board
A11: IC2.42 (PB03/16); also elsewhere on the board
A12: IC2.43 (PB04/2); also elsewhere on the board
A13: IC2.44 (PB04/5); also elsewhere on the board
A14: IC2.45 (PB04/8); also elsewhere on the board
A15: IC2.46 (PB04/3); also elsewhere on the board
A16: IC2.47 (PB04/4); also elsewhere on the board
A17: IC2.48 (PB04/11); also elsewhere on the board
A18: IC2.57 (PB04/17); also elsewhere on the board
A19: IC2.56 (PB04/15); also elsewhere on the board
A20: IC2.51 (PB04/10); also elsewhere on the board
A21: IC2.52 (PB04/12); also elsewhere on the board
A22: IC2.50 (PB04/14); also elsewhere on the board
A23: IC2.49 (PB04/6); also elsewhere on the board
BUS_INT: IC2.22 (PB03/2); also elsewhere on the board
CPUCLK_A: IC2.15 (GCLK1); also elsewhere on the board
D24: IC2.63 (PB02/8); also elsewhere on the board
D25: IC2.61 (PB02/5); also elsewhere on the board
D26: IC2.1 (PB02/10); also elsewhere on the board
D27: IC2.60 (PB02/2); also elsewhere on the board
D28: IC2.62 (PB02/6); also elsewhere on the board
D29: IC2.59 (PB02/4); also elsewhere on the board
D30: IC2.64 (PB02/9); also elsewhere on the board
D31: IC2.58 (PB02/3); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, IC2.14 (GND), IC2.21 (GND), IC2.41 (GND), IC2.54 (GND), JTAG.5; also elsewhere on the board
INTSIG1: IC2.20 (PB01/17); also elsewhere on the board
INTSIG2: IC2.23 (PB01/12); also elsewhere on the board
INTSIG3: IC2.24 (PB03/5); also elsewhere on the board
INTSIG4: IC2.13 (PB01/4); also elsewhere on the board
INTSIG5: IC2.12 (PB01/3); also elsewhere on the board
INTSIG6: IC2.11 (PB01/8); also elsewhere on the board
INTSIG7: IC2.10 (PB01/6); also elsewhere on the board
INTSIG8: IC2.18 (PB01/10); also elsewhere on the board
PUNT_IN: IC2.9 (PB01/5), R1.1; also elsewhere on the board
PUNT_OUT: IC2.8 (PB01/2); also elsewhere on the board
R_W: IC2.5 (PB02/14); also elsewhere on the board
SPI2_CK: IC2.16 (GCLK2); also elsewhere on the board
SPI2_MISO: IC2.19 (PB01/15); also elsewhere on the board
SPI2_MOSI: IC2.17 (PB01/14); also elsewhere on the board
TCK: IC2.30 (TCK), JTAG.4
TDI: IC2.28 (TDI), JTAG.2
TDO: IC2.53 (TDO), JTAG.3
TMS: IC2.29 (TMS), JTAG.1
VCC: R1.2; also elsewhere on the board
VCC33: C17.1, C18.1, C19.1, C20.1, C21.1, IC2.3 (VCCINT), IC2.26 (VCCIO), IC2.37 (VCCINT/VPP), IC2.55 (VCCIO), JTAG.6; also elsewhere on the board
_AS: IC2.2 (PB02/11); also elsewhere on the board
_DS: IC2.4 (PB02/12); also elsewhere on the board
_DSACK_0: IC2.7 (PB02/17); also elsewhere on the board
_DSACK_1: IC2.6 (PB02/15); also elsewhere on the board

Board: 4 copper layers, 124.5 x 60.0 mm, 55 parts (13 on the bottom side), 197 nets.

## Code that names these connections

File firmware/test_stuff/test_stuff.ioc (part):

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Mcu.Name=STM32F105R(8-B-C)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F105RBTx
PA11.Mode=Host_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Host_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=NSS_Signal_Hard_Output
PA15.Signal=SPI3_NSS
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI3_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI3_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI3_MOSI
PC12.Mode=Asynchronous
PC12.Signal=UART5_TX
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
PD2.Mode=Asynchronous
PD2.Signal=UART5_RX
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File boards/rev0/cd32_riserr0.ucf:

# Copyright (C) 2016-2020, Stephen J. Leary
# All rights reserved.
#
# This file is part of CD32 USB Riser
#
# This is free software: you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation, either version 3 of the License, or
# (at your option) any later version.
#
# This is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
#
# You should have received a copy of the GNU General Public License
# along with CD32 Riser. If not, see <http://www.gnu.org/licenses/>.

NET "A<0>"      LOC="27";
NET "A<1>"      LOC="25";
NET "A<2>"      LOC="31";
NET "A<3>"      LOC="32";
NET "A<4>"      LOC="33";
NET "A<5>"      LOC="34";
NET "A<6>"      LOC="35";
NET "A<7>"      LOC="36";
NET "A<8>"      LOC="38";
NET "A<9>"      LOC="39";
NET "A<10>"      LOC="40";
NET "A<11>"      LOC="42";
NET "A<12>"      LOC="43";
NET "A<13>"      LOC="44";
NET "A<14>"      LOC="45";
NET "A<15>"      LOC="46";
NET "A<16>"      LOC="47";
NET "A<17>"      LOC="48";
NET "A<18>"      LOC="57";
NET "A<19>"      LOC="56";
NET "A<20>"      LOC="51";
NET "A<21>"      LOC="52";
NET "A<22>"      LOC="50";
NET "A<23>"      LOC="49";
NET "CLKCPU_A"      LOC="15";
NET "D<24>"      LOC="63";
NET "D<25>"      LOC="61";
NET "D<26>"      LOC="1";
NET "D<27>"      LOC="60";
NET "D<28>"      LOC="62";
NET "D<29>"      LOC="59";
NET "D<30>"      LOC="64";
NET "D<31>"      LOC="58";
NET "PUNT_IN"      LOC="13";
NET "PUNT_OUT"      LOC="10";
NET "RW"      LOC="7";
NET "SIZ<0>"      LOC="4";
NET "SIZ<1>"      LOC="2";
NET "SPI_CK"      LOC="20";
NET "SPI_MISO"      LOC="19";
NET "SPI_MOSI"      LOC="18";
NET "SPI_NSS"      LOC="24";
NET "UART5_RX"      LOC="22";
NET "UART5_TX"      LOC="23";
NET "AS20"      LOC="5";
NET "DS20"      LOC="6";
NET "DSACK<0>"      LOC="9";
NET "DSACK<1>"      LOC="8";
NET "KB_CLOCK"      LOC="11";
NET "KB_DATA"      LOC="12";
NET "RXD"      LOC="16";
NET "TXD"      LOC="17";

## Commit log

2020-01-01 Initial commit of the riser... some broken bits and no RTC battery yet
2020-01-01 initial dummy commit.
2020-01-01 Create LICENSE
2020-01-01 Added punt pullup
2020-01-01 Added missing 10k resistor
2020-01-01 decoupling for the CPLD.
2020-01-02 Added the user io from minimig
2020-01-19 FIxing stupid rtl issues
2020-01-19 joystick firmware override works... but not v well
2020-01-21 basic mouse direction working
2020-01-28 dumb test firmware
2020-01-28 remove metadata
2020-01-28 wiring docs
2020-02-03 updated firmware
2020-02-03 update the arm firmware
2020-03-08 ARM - STM32f105 - USB library - Support for standard USB HID Gamepad, and composite mouse and keyboard combos.
2020-03-09 Silly bug fix. Using uint8_t as array.
2020-03-21 updated the arm side of stuff significantly
2020-03-22 updated the circuit and added fuses
2020-03-22 added the address lines
2020-03-22 finished the route
2020-03-22 Resistor value cleanup
2020-10-13 fix vcap
2020-10-13 Added LSE oscillator. Removed TXD/RXD and added A5.
2020-10-13 minor board changes
2020-10-14 rationalized cap sizes
2020-10-14 updated footprint of 32Khz crystal
2020-10-14 updated silkscreen

Notices in the files:
eagle/cd32_riser.brd:
(C) 2020 S.J Leary & A Makarenko
Published Under the GNU GPLv2
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
SparkFun-Retired: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
